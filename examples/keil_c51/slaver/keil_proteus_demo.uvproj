# Keil uVision project keil_proteus_demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: keil_proteus_demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ucos;.\ming_mcu_single_line
  group Source Group 1
    ./: main.c Main_constant.h subprogram.c Function.h
    ./ming_mcu_single_line/: ming_mcu_single_line.c
  group ucos
    ../ucos/: ucos.c
